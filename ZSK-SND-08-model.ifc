Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:46+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcFurnishingElement: Песочница, ZSK-SND-08 Песочный дворик «Вода и песок»
In: Площадка
Description: Песочница. Песочный дворик «Вода и песок»; Material: лиственница, влагостойкая фанера с УФ-печатью под лаком, нер
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-SND-08; ModelReference: Песочный дворик «Вода и песок»; ProductionYear: 2026; ArticleNumber: ZSK-SND-08
ORION_Изделие - Артикул: ZSK-SND-08; Артикул прежний: SD-SND-08; Наименование: Песочный дворик «Вода и песок»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 3200×2000×900 мм; Возраст: 2–8 лет; Материал: лиственница, влагостойкая фанера с УФ-печатью под лаком, нержавеющий крепёж и фурнитура; Цена: от 590 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/sandboxes/21008
ADSK - ADSK_Наименование: Песочный дворик «Вода и песок»; ADSK_Марка: ZSK-SND-08; ADSK_Код изделия: ZSK-SND-08; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: лиственница, влагостойкая фанера с УФ-печатью под лаком, нержавеющий крепёж и фурнитура; ADSK_URL страницы изделия: https://зск.рф/catalog/sandboxes/21008
ZSK_Благоустройство - ZSK_Возрастная_группа: 2–8 лет; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Артикул_прежний: SD-SND-08
Qto_ORION - Длина: 3200 mm; Ширина: 2000 mm; Высота: 900 mm
